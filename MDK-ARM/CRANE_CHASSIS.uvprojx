# Keil uVision project CRANE_CHASSIS.uvprojx, settings and files
target CRANE_CHASSIS (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CRANE_CHASSIS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../HARDWARE;../HARDWARE/wit_c_sdk;../HARDWARE/CANBUS;../HARDWARE/DR16_RC;../HARDWARE/lightFlow;../HARDWARE/Algorithm;../HARDWARE/vofa
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/: ControlTask.c ControlTask.h MotorControlTask.c MotorControlTask.h TrajTrack.c TrajTrack.h XYPath.c XYPath.h MapCoords.h Pid.c Pid.h mytype.h Paraminit.c Paraminit.h user_lib.h
  group WIT_IMU
    ../HARDWARE/wit_c_sdk/: REG.h wit_c_sdk.c wit_c_sdk.h
  group CANBUS
    ../HARDWARE/CANBUS/: CanBus_Task.c CanBus_Task.h
  group LIGHTFLOW
    ../HARDWARE/lightFlow/: check.c check.h flow_decode.c flow_decode.h
  group DR16_RC
    ../HARDWARE/DR16_RC/: RC_Task.c RC_Task.h
  group Algorithm
    ../HARDWARE/Algorithm/: kalman.c kalman.h
  group COMMAND
    ../HARDWARE/vofa/: uart_comm.c uart_comm.h vofaPlus.c vofaPlus.h
software components: CMSIS:CORE 4.3.0
